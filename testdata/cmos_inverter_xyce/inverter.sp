; Generated by Arya

.subckt inverter in out vpwr vgnd
* d g s b
x0 out in vpwr vpwr sky130_fd_pr__pfet_01v8
x1 out in vgnd vgnd sky130_fd_pr__nfet_01v8
.ends
